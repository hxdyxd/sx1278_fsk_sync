# Keil uVision project led.uvprojx, settings and files
target sx1278_fsk_sync (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\User\app;..\src\hardware\CMSIS\CM3\CoreSupport;..\src\hardware\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\hardware\STM32F10x_StdPeriph_Driver\inc;..\src\hal;..\src\app;..\src\hardware;..\src\app\lora\libLoRa;..\src\app\lora\lora_net
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../src/hardware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../src/hardware/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/hardware/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../src/hardware/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    ../src/hardware/: flash.c interface_usart.c keys.c leds.c stm32f10x_it.c systick.c stm32_lora_spi.c
  group Hal
    ../src/hal/: data_interface_hal.c
  group User
    ../src/app/: main.c soft_timer.c
  group LORA
    ../src/app/lora/libLoRa/: sx1276-Fsk.c sx1276-FskMisc.c
    ../src/app/lora/lora_net/: lora_net.c
